# Copyright (c) 2026 Nagesh Sonwane <nagesh.sonwane@hotmail.com>
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
